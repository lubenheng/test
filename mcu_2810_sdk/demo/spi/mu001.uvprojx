# Keil uVision project mu001.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: OCD2810BP64 ORIENT-CHIP
  pack: ORIENT-CHIP.OCD2810_DFP.0.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x08000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: mu001 +hex
  BeforeMake: $K\ARM\ARMCC\BIN\fromelf.exe --text -a -c --output=@L_asm.txt "!L"
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe --bin --output .\image.bin Objects\mu001.axf
  AfterMake: ..\..\tools\combine.exe
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\system\source;..\..\tools\SEGGER_RTT;..\..\system\code\head\0_user_h;..\..\system\code\head\1_motlib_h;..\..\system\hal;..\..\system\cmdline
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\soc_eg.sct
  group Driver
    ../../system/source/: acmp.c adc.c ccp.c div.c drv.c foc.c gpio.c mdu.c pga.c pmu.c qspi.c timer.c uart.c wdt.c
  group SEGGER_RTT
    ../../tools/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group user_s
    ../../system/source/: INIT.c
    ./: main.c
    ../../system/code/source/0_user_s/: hardinit.c mc_ctrl.c mc_foc.c softinit.c
  group user_file
    ../../system/code/head/0_user_h/: para_define.h user_control.h
    ../../system/code/head/1_motlib_h/: mc_pmsm.h
  group device
    ../../system/source/: startup_CMSDK_CM0.s system_CMSDK_CM0.c
  group hal
    ../../system/hal/: gpio_hal.c SPI_hal .c
  group cmdline
    ../../system/cmdline/: cmdline_internal.c uart_cmd.c utility.c test.c gpio_cmdline.c spi_cmdline.c
