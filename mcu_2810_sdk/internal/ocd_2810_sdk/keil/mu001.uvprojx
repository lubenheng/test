# Keil uVision project mu001.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: OCD2810BP64 ORIENT-CHIP
  pack: ORIENT-CHIP.OCD2810_DFP.0.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x08000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: mu001 +hex
  BeforeMake: $K\ARM\ARMCC\BIN\fromelf.exe --text -a -c --output=@L_asm.txt "!L"
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe --bin --output .\image.bin Objects\mu001.axf
  AfterMake: .\combine.exe
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\source;..\source\SEGGER_RTT;..\code\head\0_user_h;..\code\head\1_motlib_h;..\SEGGER_RTT
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\soc_eg.sct
  group Driver
    ../source/: gpio.c qspi.c uart.c timer.c wdt.c mdu.c pmu.c adc.c drv.c foc.c pga.c acmp.c ccp.c div.c rtc.c
  group SEGGER_RTT
    ../SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group user_s
    ../source/: INIT.c
    ../code/source/0_user_s/: main.c mc_foc.c mc_ctrl.c hardinit.c softinit.c
  group user_file
    ../code/head/0_user_h/: para_define.h user_control.h
    ../code/head/1_motlib_h/: mc_pmsm.h
  group device
    ../source/: system_CMSDK_CM0.c startup_CMSDK_CM0.s
