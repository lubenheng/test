# Keil uVision project 5010.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: 5010 +hex
  AfterMake: fromelf.exe --bincombined "!L" --output="$L\@L.bin"
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_ODS5010
  c include: ..\..\system\common;..\..\system\cmsis\include;..\..\system\core;..\..\system\peripherals;..\..\system\hal;..\..\system\device;..\..\internal;..\..\system\device\ODS_5010\include;..\cmdline;..\..\system\core\ODS_5010;..\test;..\..\code\source\0_global_s;..\..\code\source\1_driver_s;..\..\code\source\2_app_s;..\..\code\source\3_user_s;..\..\code\source\4_motlib_s;..\..\code\head\0_global_h;..\..\code\head\1_drive_h;..\..\code\head\2_app_h;..\..\code\head\3_user_h;..\..\code\head\4_motlib_h;..\..\bldc_code\head\0_global_h;..\..\bldc_code\head\1_driver_h;..\..\bldc_code\head\2_user_h;..\..\bldc_code\head\3_motor_h;..\..\bldc_code\source\0_global_s;..\..\bldc_code\source\1_driver_s;..\..\bldc_code\source\2_user_s;..\..\bldc_code\source\3_motor_s;..\..\bldc_code\source\4_lib;..\..\system\peripherals\ADC;..\..\system\peripherals\Math;..\..\system\hal\Math;..\test\HWMath
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\..\tools\MDK\ODS5010A_link_mdk.sct
  group internal
    ./: main.c
  group hal
    ../../system/hal/: gpio_hal.c gpio_hal_cfg.c mcpwm_hal.c mcpwm_hal_cfg.c flash_hal.c uart_hal.c uart_hal_cfg.c adc_hal.c adc_hal_cfg.c can_hal.c can_hal_cfg.c clock_hal.c clock_hal_cfg.c i2c_hal.c i2c_hal_cfg.c spi_hal.c spi_hal_cfg.c module_hal.c module_hal_cfg.c wdog_hal.c hall_hal.c hall_hal_cfg.c qep_hal.c TIM_hal.c pmu_hal.c pmu_hal_cfg.c dma_hal.c
  group core
    ../../system/core/: HardFaultHandler.c
  group common
    ../../system/common/: console.c version.c isr.c utility.c ctype.c
  group peripherals
    ../../system/peripherals/: can.c clock.c flash.c gpio.c gpt.c pmu.c rtc.c scm.c spi.c uart.c wdog.c mcpwm.c module.c dma.c i2c.c hall.c qep.c RCC.c TIM.c CSA.c
    ../../system/peripherals/ADC/: adc.c
    ../../system/peripherals/Math/: HW_Math.c
  group test
    ../test/: test.c gpio_test.c mcpwm_test.c module_test.c adc_test.c can_test.c hall_test.c i2c_test.c qep_test.c rtc_test.c spi_test.c wdog_test.c clock_test.c dma_test.c TIM_test.c flash_test.c pmu_test.c CSA_test.c
    ../../code/head/3_user_h/: user_control.h para_define.h
    ../test/HWMath/: HwMath_test.c
  group cmdline
    ../cmdline/: cmdline_internal.c gpio_cmdline.c uart_cmdline.c mcpwm_cmdline.c adc_cmdline.c module_cmdline.c HWMath_Cmdline.c can_cmdline.c clock_cmdline.c hall_cmdline.c i2c_cmdline.c qep_cmdline.c rtc_cmdline.c spi_cmdline.c wdog_cmdline.c dma_cmdline.c TIM_cmdline.c flash_cmdline.c pmu_cmdline.c
  group device
    ../../system/device/: system_ARMCM0plus.c
    ../../system/device/ODS_5010/startup/MDK/: startup_ARMCM0plus.s
  group can
    ../../system/hal/: can_basic.c can_busoff.c can_wkup.c
  group foc_user_s
    ../../code/source/3_user_s/: mc_foc.c mc_ctrl.c hardinit.c softinit.c
  group foc_motlib_s
    ../../code/source/4_motlib_s/: mc_pic.c mc_UniShunt.lib mc_pmsm_260727.lib
  group 2_bldc_user_h
    ../../bldc_code/head/2_user_h/: bldc_main.h bldc_user_bsp.h bldc_user_config.h
  group 2_bldc_user_s
    ../../bldc_code/source/2_user_s/: bldc_user_control.c bldc_public_function.c
  group 3_bldc_motor_h
    ../../bldc_code/head/3_motor_h/: bldc_motor_control.h bldc_public_function.h
  group 3_bldc_motor_s
    ../../bldc_code/source/3_motor_s/: bldc_motor_control.c bldc_motor_state.c bldc_public_debug.c bldc_motor_hall.c
  group 4_bldc_lib
    ../../bldc_code/source/4_lib/: bldc_bsp_lib.c bldc_motor_mlib.c
