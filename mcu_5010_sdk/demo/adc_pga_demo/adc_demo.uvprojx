# Keil uVision project adc_demo.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: gpio_demo +hex
  AfterMake: fromelf.exe --bincombined "!L" --output="$L\@L.bin"
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_ODS5010
  c include: ..\..\system\common;..\..\system\cmsis\include;..\..\system\core;..\..\system\peripherals;..\..\system\hal;..\..\system\device;..\..\internal;..\..\system\device\ODS_5010\include;..\..\internal\cmdline;..\..\internal\test;..\..\system\peripherals\ADC;.\adc_demo_test
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\..\tools\MDK\ODS5010A_link_mdk.sct
  group demo
    ./: main.c
  group hal
    ../../system/hal/: gpio_hal.c uart_hal.c uart_hal_cfg.c clock_hal.c clock_hal_cfg.c pmu_hal.c pmu_hal_cfg.c mcpwm_hal.c mcpwm_hal_cfg.c
  group core
    ../../system/core/: HardFaultHandler.c
  group common
    ../../system/common/: console.c ctype.c utility.c version.c
    ./: isr.c
  group peripherals
    ../../system/peripherals/: gpio.c pmu.c uart.c clock.c mcpwm.c CSA.c TIM.c
    ../../system/peripherals/ADC/: adc.c
  group device
    ../../system/device/: system_ARMCM0plus.c
    ../../system/device/ODS_5010/startup/MDK/: startup_ARMCM0plus.s
  group cmdline
    ../../internal/cmdline/: cmdline_internal.c
  group test
    ./adc_demo_test/: adc_demo_test.c adc_demo_test.h
